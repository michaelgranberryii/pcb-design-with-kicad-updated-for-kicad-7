# Repository michaelgranberryii/pcb-design-with-kicad-updated-for-kicad-7

## KiCad design mcu-datalogger/mcu-datalogger.kicad_pcb

Parts:
BT1: Battery; PinHeader_1x02_P2.54mm_Vertical
C1, C4: 0.1uF; C_0805_2012Metric
C2, C3: 22pF; C_0805_2012Metric
C5: 100nF; C_0805_2012Metric
D1, D2: LED; LED_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.1mm
R1, R6: 4.7k; R_0805_2012Metric
R2, R3, R7: 10K; R_0805_2012Metric
R4, R5: 330; R_0805_2012Metric
U1, U2: 24LC1025; SOIC-8_5.23x5.23mm_P1.27mm
U3: DS1337S_; SOIC127P600X175-8N
U4: ATMEGA328P-AU; QFP80P900X900X120-32N; PARTREV 8271A
Y1: 16MHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering
Y2: 32.768 KHz; Crystal_SMD_5032-2Pin_5.0x3.2mm_HandSoldering

Connections:
/D2: U4.32 (PD2); also elsewhere on the board
/D3: U4.1 (PD3); also elsewhere on the board
/D4: U4.2 (PD4); also elsewhere on the board
/D5: U4.9 (PD5); also elsewhere on the board
/D6: U4.10 (PD6); also elsewhere on the board
/D7: U4.11 (PD7); also elsewhere on the board
/D8: U4.12 (PB0); also elsewhere on the board
/MISO: U4.16 (PB4); also elsewhere on the board
/MOSI: U4.15 (PB3); also elsewhere on the board
/RESET: R7.2, U4.29 (PC6/~RESET); also elsewhere on the board
/RX: U4.30 (PD0); also elsewhere on the board
/SCK: D2.2 (A), R6.2, U1.6 (SCL), U2.6 (SCL), U3.6 (SCL), U4.17 (PB5), U4.28 (PC5); also elsewhere on the board
/SDA: R1.2, U1.5 (SDA), U2.5 (SDA), U3.5 (SDA), U4.27 (PC4); also elsewhere on the board
/TX: U4.31 (PD1); also elsewhere on the board
/Vcc: BT1.1 (+), C1.1, C5.1, D1.2 (A), R1.1, R2.1, R3.1, R6.1, R7.1, U1.1 (A0), U1.2 (A1), U1.3 (A2), U1.8 (VCC), U2.1 (A0), U2.3 (A2), U2.8 (VCC), U3.8 (VCC), U4.4 (VCC), U4.18 (AVCC); also elsewhere on the board
GND: BT1.2 (-), C1.2, C2.1, C3.1, C4.1, C5.2, R4.1, R5.2, U1.4 (GND), U1.7 (WP), U2.2 (A1), U2.4 (GND), U2.7 (WP), U3.4 (GND), U4.3 (GND), U4.5 (GND), U4.21 (GND); also elsewhere on the board
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R4.2
unnamed: R2.2, U3.7 (SQW/~INT)
unnamed: U3.1 (X1), Y2.2
unnamed: U3.2 (X2), Y2.1
unnamed: R3.2, U3.3 (~INTA)
unnamed: C4.2, U4.20 (AREF)
unnamed: C3.2, U4.7 (PB6), Y1.1
unnamed: C2.2, U4.8 (PB7), Y1.2

Notes on the sheet:
Real time clock
EEPROM
Mounting
MCU

Parts:
J1, J2: Conn_01x04_Pin; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x09_Pin; PinHeader_1x09_P2.54mm_Vertical
J4: Conn_02x03_Odd_Even; PinHeader_2x03_P2.54mm_Vertical

Connections:
/D2: J3.1; also elsewhere on the board
/D3: J3.2; also elsewhere on the board
/D4: J3.3; also elsewhere on the board
/D5: J3.4; also elsewhere on the board
/D6: J3.5; also elsewhere on the board
/D7: J3.6; also elsewhere on the board
/D8: J3.7; also elsewhere on the board
/MISO: J4.1; also elsewhere on the board
/MOSI: J4.4; also elsewhere on the board
/RESET: J4.5; also elsewhere on the board
/RX: J2.3; also elsewhere on the board
/SCK: J1.4, J4.3; also elsewhere on the board
/SDA: J1.3; also elsewhere on the board
/TX: J2.4; also elsewhere on the board
/Vcc: J1.2, J2.2, J3.9, J4.2; also elsewhere on the board
GND: J1.1, J2.1, J3.8, J4.6; also elsewhere on the board

Board: 4 copper layers, 55.2 x 36.0 mm, 29 parts (0 on the bottom side), 25 nets.

## KiCad design breadboard-power-supply/breadboard-power-supply.kicad_pcb

Parts:
C1: 10u; C_Disc_D3.0mm_W1.6mm_P2.50mm
C2: 0.1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
C3: 1u; C_Disc_D3.0mm_W1.6mm_P2.50mm
D1: LED; LED_D5.0mm
J1, J2: Conn_01x02_Pin; PinHeader_1x02_P2.54mm_Vertical
J3, J4: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J5, J7: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J6: Barrel_Jack_Switch; BarrelJack_Horizontal
R1, R2: 330; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R3: 560; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
SW1: EG1218; SW_Slide-03_Wuerth-WS-SLTV_10x2.5x6.4_P2.54mm
U1: LM7805_TO220; TO-220-3_Vertical
U2: LM317_TO-220; TO-220-3_Vertical

Connections:
/3.3V: C3.1, J3.1, J4.1, R2.2, U2.2 (VO)
/5V: C2.1, J3.3, J4.3, U1.3 (VO)
/12V: C1.1, R1.2, SW1.2, U1.1 (VI), U2.3 (VI)
/PWR_input: J6.1, SW1.1
/PWR_output: J1.2, J2.2, J3.2, J4.2, J5.2, J7.2
GND: C1.2, C2.2, C3.2, D1.1 (K), J1.1, J2.1, J5.1, J6.2, J6.3, J7.1, R3.1, U1.2 (GND)
unnamed: D1.2 (A), R1.1
unnamed: R2.1, R3.2, U2.1 (ADJ)

Notes on the sheet:
I flipped screw terminals so that pin 1 is GND
Output and Switches
3.3V Circuit
Input and 5V ciruit

Board: 2 copper layers, 32.0 x 53.2 mm, 17 parts (0 on the bottom side), 8 nets.

## KiCad design proj1-led-torch/proj1-led-torch.kicad_pcb

Board: 2 copper layers, 65.5 x 24.8 mm, 4 parts (0 on the bottom side), 4 nets.

Parts:
BT1: Battery; BatteryHolder_Keystone_1058_1x2032
D1: LED; LED_D5.0mm
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_DPST_x2; SW_TH_Tactile_Omron_B3F-10xx

Connections:
/Bat_pos: BT1.1 (+), SW1.2 (B)
/LED_anode: D1.2 (A), R1.1
/LED_cathode: BT1.2 (-), D1.1 (K)
unnamed: R1.2, SW1.1 (A)

## Commit log

2024-04-02 added project Led Torch
2024-04-02 finished LED Torch
2024-05-06 added files
2024-05-08 untracked
2024-05-08 added breadboard power supply project
2024-05-08 added .gitignore
2024-05-10 updated git ignore
2024-05-10 adding symbols to schematic
2024-05-10 arranged symbols
2024-05-10 updated symbol values
2024-05-13 updated .gitignore
2024-05-13 associated footprints with symbols
2024-05-13 added nets to root schematic
2024-05-13 updated nets on both schematics
2024-05-13 alocated GND and Vcc to Power net class
2024-05-13 added comments
2024-05-13 setup pcb
2024-05-13 placed footplrints
2024-05-14 routed pcb
2024-05-14 routing complete
2024-05-14 updated pcb and fixed bat Vcc
2024-05-14 finished 2-layer pcb
2024-05-14 added 3d models
2024-05-14 updated file structure
2024-05-14 updated gitignore
2024-05-14 completed 4 layer routing
2024-05-14 added board characteristics
